## Firmware/boards/shields/lucky15/Kconfig.defconfig
```kconfig
if SHIELD_LUCKY15

config ZMK_KEYBOARD_NAME
    default "Lucky15"

endif # SHIELD_LUCKY15
```
